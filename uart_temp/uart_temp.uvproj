# Keil uVision project uart_temp.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: uart_temp +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c uart.c delay.c tim.c hc138.c seg.c dkey.c iic.c onewire.c beep.c
